# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\pt-1.4;..\..\letter-shell\src;..\..\fal\inc;..\..\FlashDB\inc;..\..\MultiTimer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep shellCommand*
  group App
    ../../User/app/src/: main.c
  group BSP
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_spi_bus.c bsp_spi_flash.c bsp_timer.c bsp_uart_fifo.c
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_flash.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group pt-1.4
    ../../pt-1.4/: lc.h lc-switch.h pt.h pt-sem.h
  group letter-shell
    ../../letter-shell/src/: shell_ext.h shell_cfg.h shell.h shell_ext.c shell_companion.c shell_cmd_list.c shell.c
  group fal
    ../../fal/src/: fal.c fal_flash.c fal_partition.c fal_flash_stm32f1_port.c
  group FlashDB
    ../../FlashDB/src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FlashDB_Sample
    ../../FlashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c sample_main.c
  group MultiTimer
    ../../MultiTimer/: multi_timer.c multi_timer.h
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
software components: CMSIS:CORE 5.6.0
